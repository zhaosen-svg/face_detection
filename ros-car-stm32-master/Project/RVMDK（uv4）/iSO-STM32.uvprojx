# Keil uVision project iSO-STM32.uvprojx, settings and files
target ros_base (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ros_base +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\SysTick;..\..\User\PID;..\..\User\contact;..\..\User\UltrasonicWave;..\..\User\spin;..\..\User\encoder;..\..\User\GPIO_conf;..\..\User\NVIC_conf;..\..\User\RCC_Conf;..\..\User\TIM2_5_6;..\..\User\usart;..\..\User\encoder;..\..\User\Delay;..\..\User\Odometry;..\..\User\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ../../User/Delay/: delay.c
    ../../User/NVIC_conf/: nvic_conf.c
    ../../User/RCC_Conf/: rcc_conf.c
    ../../User/GPIO_conf/: gpio_conf.c
    ../../User/usart/: usart.c
  group Hardware
    ../../User/Odometry/: odometry.c
    ../../User/TIM2_5_6/: tim2_5_6.c
    ../../User/contact/: contact.c
    ../../User/encoder/: encoder.c
    ../../User/PID/: PID.C
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DOC
    ../../Doc/: readme.txt
software components: CMSIS:CORE 5.0.2
